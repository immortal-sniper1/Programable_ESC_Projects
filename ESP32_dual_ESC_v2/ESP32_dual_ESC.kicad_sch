File: ESP32_dual_ESC_v2/ESP32_dual_ESC.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 3
Other:
- sheet ESC_V2: file ESC_V2.kicad_sch -> ESC_V1.kicad_sch
